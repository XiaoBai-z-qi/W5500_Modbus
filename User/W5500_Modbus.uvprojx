# Keil uVision project W5500_Modbus.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: W5500_Modbus
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F411xE,USE_STDPERIPH_DRIVER
  c include: ..\User;..\bsp;..\platform;..\Drivers\CMSIS;..\Drivers\stm32f4xx\Inc;..\Drivers\stm32f4xx\Src;..\Drivers\w5500;..\Drivers\w5500\DHCP;..\Drivers\w5500\DNS;..\Drivers\w5500\W5500;..\FreeRTOS\Src;..\FreeRTOS\Inc;.\task
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ./: main.c freertos.c stm32f4xx_it.c startup_stm32f411xe.s
  group task
    ./task/: task_printf.c
  group bsp
    ../bsp/: bsp_system.c bsp_usart_printf.c
  group platform
    ../platform/: port_wizchip.c
  group Drivers/stm32f4xx
    ../Drivers/stm32f4xx/Src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/: system_stm32f4xx.c
  group Drivers/w5500
    ../Drivers/w5500/: socket.c wizchip_conf.c
    ../Drivers/w5500/W5500/: w5500.c
    ../Drivers/w5500/DNS/: dns.c
    ../Drivers/w5500/DHCP/: dhcp.c
  group FreeRTOS
    ../FreeRTOS/Src/: croutine.c event_groups.c heap_4.c list.c port.c queue.c stream_buffer.c tasks.c timers.c
